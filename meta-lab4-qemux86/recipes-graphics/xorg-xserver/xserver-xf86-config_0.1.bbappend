FILESEXTRAPATHS_prepend_lab4-qemux86 := "${THISDIR}/${PN}:"
