FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

PRINC = "1"
