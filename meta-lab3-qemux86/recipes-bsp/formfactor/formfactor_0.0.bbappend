FILESEXTRAPATHS:prepend:lab3-qemux86 := "${THISDIR}/${PN}:"

PRINC = "1"
