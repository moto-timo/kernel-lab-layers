FILESEXTRAPATHS_prepend_lab3-qemux86 := "${THISDIR}/${PN}:"
